# Keil uVision project LVGL_TP_mx_zd.uvprojx, settings and files
target LVGL_TP_mx_zd (5060528::V5.06 update 5 (build 528)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LVGL_TP_mx_zd +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../App/Inc;../UI/Inc;../S2L;../Hardware/KEY;../Hardware/RTC;../Hardware/LCD;../GUI;../GUI/lvgl;../GUI/lvgl_port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c fsmc.c rtc.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group App/Task
    ../App/Src/: task_main.c task_automode.c
  group Hardware/KEY
    ../Hardware/KEY/: KEY.c
  group Hardware/RTC
    ../Hardware/RTC/: kk_rtc.c
  group Hardware/LCD
    ../Hardware/LCD/: lcd.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_nor.c stm32f1xx_hal_sram.c stm32f1xx_hal_nand.c stm32f1xx_hal_pccard.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
software components: CMSIS:CORE 4.3.0
